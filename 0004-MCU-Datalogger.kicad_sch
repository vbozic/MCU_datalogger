File: 0004-MCU-Datalogger.kicad_sch (KiCad schematic)
At the start: 25 parts, among them U1 24LC1025, U2 24LC1025, U3 DS1337S_, U4 ATMEGA328P-AU, Y1 16 MHz, Y2 32.768 KHz

Commit message: Complete wiring in the second sheet
Connections:
- net GND: now also BT1.2 (-), C5.2
- net SCL: now also U2.6 (SCL)
- net SDA: now also U2.5 (SDA)
- net Vcc: now also U1.8 (VCC), U2.8 (VCC)
Other:
- sheet Connectors ports: added D2, D3, D4, D5, D6, D7, D8, GND, MISO, MOSI, RESET, RX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; removed none
