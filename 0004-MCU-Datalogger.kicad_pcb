# Repository vbozic/MCU_datalogger

## KiCad design 0004-MCU-Datalogger.kicad_pcb

Parts:
BT1: Battery; PinHeader_1x02_P2.54mm_Vertical
C1, C2: 22pF; C_0805_2012Metric
C3, C4: 0.1uF; C_0805_2012Metric
C5: 100nF; C_0805_2012Metric
D1, D2: LED; LED_0805_2012Metric
H1, H2, H3, H4: MountingHole; MountingHole_2.1mm
R1, R7: 330; R_0805_2012Metric
R2, R5, R6: 10K; R_0805_2012Metric
R3, R4: 4.7K; R_0805_2012Metric
U1, U2: 24LC1025; SOIC-8_5.23x5.23mm_P1.27mm
U3: DS1337S_; SOIC127P600X175-8N
U4: ATMEGA328P-AU; QFP80P900X900X120-32N; PARTREV 8271A
Y1: 16 MHz; Crystal_SMD_5032-2Pin_5.0x3.2mm_HandSoldering
Y2: 32.768 KHz; Crystal_SMD_5032-2Pin_5.0x3.2mm_HandSoldering

Connections:
/D2: U4.32 (PD2); also elsewhere on the board
/D3: U4.1 (PD3); also elsewhere on the board
/D4: U4.2 (PD4); also elsewhere on the board
/D5: U4.9 (PD5); also elsewhere on the board
/D6: U4.10 (PD6); also elsewhere on the board
/D7: U4.11 (PD7); also elsewhere on the board
/D8: U4.12 (PB0); also elsewhere on the board
/MISO: U4.16 (PB4); also elsewhere on the board
/MOSI: U4.15 (PB3); also elsewhere on the board
/RESET: R2.2, U4.29 (PC6/~RESET); also elsewhere on the board
/RX: U4.30 (PD0); also elsewhere on the board
/SCK: D2.2 (A), U4.17 (PB5); also elsewhere on the board
/SCL: R3.2, U1.6 (SCL), U2.6 (SCL), U3.6 (SCL), U4.28 (PC5); also elsewhere on the board
/SDA: R4.2, U1.5 (SDA), U2.5 (SDA), U3.5 (SDA), U4.27 (PC4); also elsewhere on the board
/TX: U4.31 (PD1); also elsewhere on the board
/Vcc: BT1.1 (+), C4.1, C5.1, D1.2 (A), R2.1, R3.1, R4.1, R5.1, R6.1, U1.1 (A0), U1.2 (A1), U1.3 (A2), U1.8 (VCC), U2.1 (A0), U2.3 (A2), U2.8 (VCC), U3.8 (VCC), U4.4 (VCC), U4.18 (AVCC); also elsewhere on the board
GND: BT1.2 (-), C1.1, C2.1, C3.1, C4.2, C5.2, R1.2, R7.1, U1.4 (GND), U1.7 (WP), U2.2 (A1), U2.4 (GND), U2.7 (WP), U3.4 (GND), U4.3 (GND), U4.5 (GND), U4.21 (GND); also elsewhere on the board
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R7.2
unnamed: R5.2, U3.7 (SQW/~INT)
unnamed: U3.1 (X1), Y2.2
unnamed: U3.2 (X2), Y2.1
unnamed: R6.2, U3.3 (~INTA)
unnamed: C3.2, U4.20 (AREF)
unnamed: C2.2, U4.7 (PB6), Y1.2
unnamed: C1.2, U4.8 (PB7), Y1.1

Notes on the sheet:
Real time clock
EEPROM
MCU
Mounting

Parts:
J1, J2: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J3: Conn_01x09_Pin; PinHeader_1x09_P2.54mm_Vertical
J4: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical

Connections:
/D2: J3.1; also elsewhere on the board
/D3: J3.2; also elsewhere on the board
/D4: J3.3; also elsewhere on the board
/D5: J3.4; also elsewhere on the board
/D6: J3.5; also elsewhere on the board
/D7: J3.6; also elsewhere on the board
/D8: J3.7; also elsewhere on the board
/MISO: J4.1; also elsewhere on the board
/MOSI: J4.4; also elsewhere on the board
/RESET: J4.5; also elsewhere on the board
/RX: J2.3; also elsewhere on the board
/SCK: J4.3; also elsewhere on the board
/SCL: J1.4; also elsewhere on the board
/SDA: J1.3; also elsewhere on the board
/TX: J2.4; also elsewhere on the board
/Vcc: J1.2, J2.2, J3.9, J4.2; also elsewhere on the board
GND: J1.1, J2.1, J3.8, J4.6; also elsewhere on the board

Board: 4 copper layers, 52.2 x 35.1 mm, 29 parts (0 on the bottom side), 26 nets.

## Commit log

2025-01-27 Add gitignore
2025-01-28 Setup of EEschema for new project
2025-01-28 Add required symbols to the schematic sheets
2025-01-28 Arrange symbols
2025-01-28 Assign values to components
2025-02-02 Completed symbol footprint associations
2025-02-02 Complete wiring of main sheet
2025-02-02 Complete wiring in the second sheet
2025-02-04 Allocate GND and Vcc nets to the Power net class
2025-02-04 Completed comments
2025-02-07 Setup PCBNew
2025-02-07 Complete placement of footprints
2025-02-09 Finish routing
2025-02-09 Finish edge cuts
2025-02-09 Add copper fills
2025-02-09 Add Vcc Net Label to a battery circuit & Fix new routing violations
2025-02-10 Fix SCK issue
2025-02-10 Fix SCK issue in PCB editor
2025-02-10 Complete 2 layer project
2025-02-10 Untrack gerber files
2025-02-12 Finalize 4-layer PCB routing
2025-02-12 Add Board Characteristics
